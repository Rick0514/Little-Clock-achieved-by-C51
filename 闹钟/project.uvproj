# Keil uVision project project.uvproj, settings and files
target project (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app;.\bsp;.\bsp\inc
  group Source Group 1
    ./: STARTUP.A51
  group app
    ./app/src/: main.c
  group bsp
    ./bsp/src/: lcd.c e2prom.c
